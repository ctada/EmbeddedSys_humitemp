# IAR project humitemp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFM32PG1B200F256GM48; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32PG1B\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\rtcdrv\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\glib\glib; ..\..\..\..\..\reptile\glib\dmd; ..; ..\..\..\..\..\emdrv\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: humitemp.bin
  ILINK.IlinkOutputFile: humitemp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group bsp
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/IAR/: startup_efm32pg1b.s
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group Drivers
    ../../../../common/drivers/: i2cspm.c retargetio.c retargetserial.c si7013.c udelay.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group emlib
    ../../../../../emlib/src/: em_adc.c em_assert.c em_cmu.c em_emu.c em_gpio.c em_i2c.c em_int.c em_leuart.c em_rtcc.c em_system.c em_usart.c
  group Source
    ../: humitemp.c
